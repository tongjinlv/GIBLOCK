# Keil uVision project GPIO.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GPIO +hex
  AfterMake: .\output\hex2bin.exe .\output\GPIO.hex
  AfterMake: .\IAP.exe -w  COM6 .\output\GPIO.bin
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source Group 1
    ./Code/: GPIO.C
