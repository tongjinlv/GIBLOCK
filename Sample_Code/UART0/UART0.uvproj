# Keil uVision project UART0.uvproj, settings and files
target micor-null (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: UART0 +hex
  AfterMake: .\output\hex2bin.exe .\output\UART0.hex
  AfterMake: .\IAP.exe -w  COM5 .\output\UART0.bin
  c flags: Optimize=2 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  link misc: "REMOVEUNUSED"
  group Source
    ./Source/: UART0.c
  group Startup
    ../../Startup/: STARTUP.A51
  group Common
    ../../Common/: Common.c Delay.c Seg.c Key.c Adc.c Ext.c Pwm.c JQ.c App.c ultrasonic.c BitLed.c
